# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\Lib\STM32_USB-FS-Device_Lib\inc;..\User\USB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../User/: system_stm32f10x.c
  group StdPeriph_Driver
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_spi.c
  group STM32_USB-FS-Device_Lib_V3.3.0
    ../Lib/STM32_USB-FS-Device_Lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    ../User/USB/: usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group User
    ../User/: platform.c main.c stm32f10x_it.c system_stm32f10x.c cyccnt_delay.c
  group Text
    ../: Readme.txt
